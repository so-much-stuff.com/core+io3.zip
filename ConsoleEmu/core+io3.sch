# EAGLE board core+io3 (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$108  (via drill 0.61) (continued)
  Top 0.254: v95.88,82.39 95.24,81.75 95.24,77.3 IC16.18 | v117.47,86.19 118.1,85.56 118.1,79.84 v116.83,78.58
  Bottom 0.254: v95.88,82.39 95.88,86.19 v117.47,86.19 | v116.83,78.58 118.74,78.58 120.01,77.3 SV5.15
N$109  (via drill 0.61)
  Top 0.254: v107.94,60.16 107.94,63.34 IC15.13
  Bottom 0.254: v107.94,60.16 118.1,60.16 118.74,59.52 120.01,59.52 SV5.1
N$110  (via drill 0.61)
  Top 0.254: v103.5,60.8 104.13,61.43 104.13,63.34 IC15.14 | v118.74,57.62 118.74,59.52 119.38,60.16 120.01,60.16 120.01,60.8 SV5.3
  Bottom 0.254: v103.5,60.8 106.04,58.25 116.2,58.25 116.83,57.62 v118.74,57.62
N$111
  Bottom 0.254: IC15.17 97.78,63.34 99.05,62.06 113.66,62.06 114.3,62.7 118.1,62.7 119.38,63.97 SV5.5
N$112
  Bottom 0.254: IC15.18 95.24,63.34 97.15,61.43 101.59,61.43 103.5,59.52 103.5,54.45 117.47,54.45 121.28,58.25 121.28,65.88 120.01,65.88 SV5.7
N$113
  Bottom 0.254: IC14.19 17.77,101.44 16.5,100.16 15.24,100.16 13.33,102.07 11.43,102.07 SV7.15
N$114
  Bottom 0.254: IC14.16 25.39,101.44 24.12,100.16 17.77,100.16 17.14,99.53 11.43,99.53 SV7.13
N$115
  Bottom 0.254: IC14.15 28.57,100.8 25.39,97.62 10.79,97.62 SV7.11
N$116  (via drill 0.61)
  Top 0.254: v12.06,103.34 12.06,95.08 11.43,94.45 SV7.9
  Bottom 0.254: v12.06,103.34 13.97,103.34 14.6,103.97 34.29,103.97 34.92,103.34 36.19,103.34 IC14.12
N$117
  Bottom 0.254: IC14.2 17.77,93.81 16.5,92.55 12.06,92.55 11.43,93.18 10.16,93.18 8.89,94.45 SV7.10
N$118  (via drill 0.61)
  Top 0.254: v26.03,99.53 26.03,95.72 IC14.5
  Bottom 0.254: v26.03,99.53 19.68,99.53 19.04,98.89 12.06,98.89 11.43,98.26 9.52,98.26 8.89,97.62 8.25,97.62 SV7.12
N$119  (via drill 0.61)
  Top 0.254: v7.62,105.25 7.62,103.34 6.98,102.7 6.98,100.16 7.62,99.53 SV7.14 | v52.7,104.61 v52.7,92.55
  Bottom 0.254: v7.62,105.25 8.25,105.88 51.43,105.88 v52.7,104.61 | v52.7,92.55 52.07,91.91 29.84,91.91 28.57,93.18 IC14.6
N$120  (via drill 0.61)
  Top 0.254: v34.92,104.61 34.92,96.99 35.55,96.36 35.55,95.08 IC14.9
  Bottom 0.254: v34.92,104.61 10.16,104.61 8.25,102.7 SV7.16
N$121  (via drill 0.61)
  Top 0.254: v9.52,95.72 9.52,92.55 8.89,91.91 SV7.8 | v39.37,96.99 37.46,96.99 37.46,84.29 36.83,83.66 36.83,82.39 IC13.9
  Bottom 0.254: v9.52,95.72 14.6,95.72 15.87,96.99 v39.37,96.99
N$122  (via drill 0.61)
  Top 0.254: v28.57,86.19 28.57,83.02 IC13.6
  Bottom 0.254: v28.57,86.19 27.93,86.83 12.7,86.83 11.43,88.1 8.89,88.1 8.25,88.73 SV7.6
N$123  (via drill 0.61)
  Top 0.254: v26.03,85.56 26.03,83.02 IC13.5
  Bottom 0.254: v26.03,85.56 25.39,86.19 12.06,86.19 11.43,85.56 8.89,85.56 8.25,86.19 SV7.4
N$124  (via drill 0.61)
  Top 0.254: v59.05,51.91 59.05,50 IC26.5 | v78.1,58.89 77.46,59.52 77.46,79.84 79.37,81.75 79.37,83.02 IC24.13
  Bottom 0.254: v59.05,51.91 59.69,51.27 69.21,51.27 76.83,58.89 v78.1,58.89
N$125  (via drill 0.61)
  Top 0.254: v75.56,82.39 76.19,81.75 76.19,59.52 v75.56,58.89 | v62.86,54.45 62.86,52.54 62.23,51.91 62.23,49.37 IC26.6
  Bottom 0.254: v75.56,82.39 81.27,82.39 81.91,83.02 IC24.14 | v75.56,58.89 74.92,58.25 71.11,58.25 70.48,57.62 70.48,54.45 v62.86,54.45
N$126  (via drill 0.61)
  Top 0.254: v78.73,60.16 v78.73,79.84 | v65.4,58.25 65.4,55.08 64.77,54.45 64.77,51.91 64.13,51.27 64.13,50 IC26.7
  Bottom 0.254: v78.73,79.84 77.46,81.11 73.02,81.11 73.02,85.56 73.66,86.19 83.81,86.19 84.45,85.56 IC24.15 | v78.73,60.16 75.56,60.16 74.29,58.89 66.03,58.89 v65.4,58.25
N$127  (via drill 0.61)
  Top 0.254: v67.94,39.2 67.94,47.46 67.3,48.09 IC26.8 | v86.35,39.2 86.99,39.84 86.99,83.02 IC24.16
  Bottom 0.254: v67.94,39.2 68.57,39.84 80,39.84 80.64,39.2 v86.35,39.2
N$128  (via drill 0.61)
  Top 0.254: v89.53,72.22 90.8,73.5 90.8,79.84 90.16,80.48 90.16,83.66 IC24.17 | v81.27,72.22 81.91,71.59 81.91,62.06 81.27,61.43 81.27,42.38 79.37,40.48 v79.37,38.57 | v70.48,38.57 70.48,44.92 69.21,46.19 69.21,47.46 IC26.9
  Bottom 0.254: v89.53,72.22 88.89,72.86 81.91,72.86 v81.27,72.22 | v79.37,38.57 79.37,39.2 71.11,39.2 v70.48,38.57
N$129
  Top 0.254: IC25.3 53.97,70.32 53.34,70.95 53.34,72.86 52.7,73.5 52.7,81.75 53.97,83.02 IC24.3
N$130
  Top 0.254: IC25.4 56.51,70.32 56.51,72.22 55.24,73.5 55.24,81.75 56.51,83.02 IC24.4
N$131
  Top 0.254: IC25.5 59.05,70.32 58.41,70.95 58.41,74.77 57.78,75.4 57.78,81.75 59.05,83.02 IC24.5
N$132
  Top 0.254: IC25.6 61.59,70.32 61.59,72.22 60.32,73.5 60.32,81.75 61.59,83.02 IC24.6
N$133
  Top 0.254: IC25.7 64.13,70.32 62.86,71.59 62.86,81.75 64.13,83.02 IC24.7
N$134
  Top 0.254: IC25.8 66.67,70.32 66.67,74.13 65.4,75.4 65.4,81.75 66.67,83.02 IC24.8
N$135
  Top 0.254: IC25.9 69.21,70.32 67.94,71.59 67.94,81.75 69.21,83.02 IC24.9
N$136  (via drill 0.61)
  Top 0.254: v50.16,39.84 50.16,44.92 49.53,45.55 49.53,48.09 IC26.1 | v80.64,40.48 82.55,42.38 82.55,60.16 83.18,60.8 83.18,78.58 80.64,81.11 v80,81.11
  Bottom 0.254: v50.16,39.84 64.13,39.84 64.77,40.48 v80.64,40.48 | v80,81.11 80.64,81.75 86.99,81.75 88.26,83.02 88.26,86.19 93.97,86.19 94.61,85.56 IC24.19
N$137
  Top 0.254: IC25.1 48.89,70.32 47.62,71.59 47.62,94.45 51.43,98.26 IC24.39
N$138  (via drill 0.61)
  Top 0.254: v78.1,101.44 78.1,102.07 v80.64,104.61 | v120.64,104.61 120.01,103.97 120.01,100.16 120.64,99.53 120.64,96.36 125.09,91.91 125.09,84.92 126.36,83.66 126.36,75.4 127.63,74.13 127.63,34.12 126.99,33.49 126.99,30.95 125.72,29.68 125.72,22.7 126.99,21.42 v126.99,8.73
  Bottom 0.254: v78.1,101.44 49.53,101.44 48.89,100.8 IC24.40 | v80.64,104.61 81.27,105.25 120.01,105.25 v120.64,104.61 | v126.99,8.73 163.82,8.73 164.46,9.36 164.46,11.9 169.54,11.9 170.17,11.27 172.08,11.27 172.72,10.63 174.62,10.63 IC27.9
N$140
  Top 0.254: IC27.8 177.16,8.09 177.79,8.09 C4.1 | IC27.12 176.53,17.61 182.88,11.27 182.88,10.63 R4.1
  Bottom 0.254: R4.1 182.88,10.63 180.34,8.09 179.06,8.09 C4.1
N$141
  Top 0.254: R4.2 182.88,18.25 181.6,18.25 R3.1 180.97,18.88 180.97,20.79 177.16,20.79 IC27.13
N$142
  Bottom 0.254: IC27.11 177.16,15.71 185.41,15.71 C5.1
N$143
  Top 0.254: R10.1 167.63,3.01 166.37,4.28 166.37,4.92 R11.E
N$144
  Bottom 0.254: X1.4 142.87,15.08 143.5,14.44 148.59,14.44 149.22,13.81 X1.6
N$145
  Top 0.254: X1.8 144.78,13.17 146.04,13.17 X1.7
N$146
  Top 0.254: X1.G2 135.25,15.08 139.69,15.08 X1.5 140.33,15.08 140.33,14.44 155.57,14.44 X1.G1
N$147  (via drill 0.61)
  Top 0.254: IC18.13 206.37,17.61 206.37,16.34 IC18.12 | v187.32,58.89 187.32,83.02 187.95,83.66 IC21.5 | v212.09,57.62 212.72,56.98 212.72,37.94 v212.09,37.3
  Bottom 0.254: v187.32,58.89 193.67,58.89 194.94,57.62 v212.09,57.62 | v212.09,37.3 214.62,34.76 214.62,18.25 207.64,18.25 IC18.13
N$148
  Top 0.254: LED1.K 208.91,11.27 207.64,12.54 207.64,13.17 IC18.11
N$149
  Bottom 0.254: R12.1 179.06,18.25 180.34,16.98 202.56,16.98 205.1,14.44 208.91,14.44 211.45,11.9 211.45,11.27 LED1.A
N$150
  Top 0.254: R13.2 176.53,104.61 177.79,104.61 JP2.1 178.43,103.34 178.43,100.8 IC21.24
N$151
  Top 0.254: IC28.4 200.02,58.89 198.12,56.98 198.12,39.2 200.02,37.3 203.19,37.3 203.19,25.23 201.92,23.96 201.92,8.09 204.47,5.55 205.1,5.55 IC18.8
N$152  (via drill 0.61)
  Top 0.254: v213.35,34.76 214.62,36.03 214.62,62.7 v213.35,63.97
  Bottom 0.254: v213.35,34.76 202.56,34.76 201.92,34.12 IC19.5 | v213.35,63.97 210.18,63.97 IC28.15
N$153
  Top 0.254: IC20.7 154.94,25.23 156.2,25.23 IC20.8
N$154
  Bottom 0.254: C7.1 147.31,20.79 147.95,20.15 166.37,20.15 167.63,18.88 IC27.3
N$155
  Top 0.254: IC20.5 149.85,26.5 154.3,30.95 158.75,30.95 158.75,33.49 C9.2
N$156
  Bottom 0.254: IC20.4 147.31,26.5 149.22,28.41 158.75,28.41 C9.1
N$157
  Top 0.254: C8.2 136.52,30.31 135.25,29.04 135.25,25.23 140.97,19.52 143.5,19.52 143.5,25.23 IC20.3
N$158
  Top 0.254: C8.1 137.16,25.87 138.42,25.87 IC20.1
N$159
  Bottom 0.254: C11.1 147.31,23.33 147.95,23.96 149.85,23.96 151.12,25.23 IC20.6
N$160
  Top 0.254: C10.2 139.69,23.33 140.97,24.6 140.97,25.23 IC20.2
NMI\
  Top 0.254: IC17.6 179.7,61.43 179.06,61.43 R6.1 178.43,62.06 177.16,63.34 177.16,86.19 191.76,86.19 193.03,84.92 IC21.7
OUT00  (via drill 0.61)
  Top 0.254: v41.27,13.17 v41.27,28.41
  Bottom 0.254: v41.27,13.17 39.37,13.17 IC6.11 | v41.27,28.41 45.72,28.41 IC1.1
OUT01
  Bottom 0.254: IC7.11 39.37,25.87 46.35,25.87 48.26,27.77 IC1.2
OUT02  (via drill 0.61)
  Top 0.254: v52.7,38.57 52.07,37.94 52.07,29.04 IC1.3
  Bottom 0.254: v52.7,38.57 39.37,38.57 IC8.11
OUT03
  Top 0.254: IC1.4 53.97,27.14 54.61,26.5 54.61,22.7 55.24,22.06 55.24,19.52 54.61,18.88 45.08,18.88 45.08,22.7 41.91,25.87 41.91,27.77 42.54,28.41 41.27,29.68 40,29.68 39.37,29.04 37.46,29.04 37.46,33.49 34.92,36.03 34.92,39.84 37.46,42.38 37.46,46.19 38.73,47.46 38.73,50 IC10.11
OUT04  (via drill 0.61)
  Top 0.254: v57.78,65.88 57.78,42.38 57.15,41.74 57.15,29.04 IC1.5
  Bottom 0.254: v57.78,65.88 57.15,66.51 40,66.51 38.73,65.24 IC11.11
OUT05  (via drill 0.61)
  Top 0.254: v59.05,34.76 59.05,29.68 IC1.6 | v42.54,34.76 41.91,35.39 41.91,50 43.18,51.27 42.54,51.91 42.54,54.45 41.91,55.08 41.91,62.06 41.27,62.7 41.27,67.14 41.91,67.78 v41.91,76.67
  Bottom 0.254: v42.54,34.76 v59.05,34.76 | v41.91,76.67 39.37,76.67 IC12.11
OUT06  (via drill 0.61)
  Top 0.254: v61.59,37.94 61.59,29.68 IC1.7 | v86.99,37.3 86.99,38.57 87.62,39.2 87.62,77.94 v88.26,78.58 | v37.46,78.58 37.46,83.02 38.1,83.66 38.1,85.56 38.73,86.19 38.73,88.1 IC13.11
  Bottom 0.254: v61.59,37.94 62.23,37.3 v86.99,37.3 | v88.26,78.58 78.73,78.58 76.83,80.48 72.38,80.48 71.75,81.11 70.48,79.84 53.34,79.84 51.43,81.75 46.98,81.75 46.35,82.39 41.91,82.39 38.1,78.58 v37.46,78.58
OUT07  (via drill 0.61)
  Top 0.254: v76.83,26.5 77.46,27.14 77.46,36.66 76.83,37.3 v76.83,53.81 | v130.81,63.34 130.17,63.97 130.17,93.81 v130.81,94.45
  Bottom 0.254: v76.83,26.5 64.77,26.5 64.13,27.14 IC1.8 | v76.83,53.81 120.01,53.81 124.45,58.25 125.72,58.25 v130.81,63.34 | v130.81,94.45 130.17,93.81 118.74,93.81 118.1,93.18 114.3,93.18 113.66,92.55 109.21,92.55 108.58,91.91 93.97,91.91 93.34,92.55 90.8,92.55 89.53,93.81 82.55,93.81 81.91,93.18 76.19,93.18 75.56,93.81 73.02,93.81 69.84,96.99 56.51,96.99 55.88,97.62 46.98,97.62 42.54,102.07 39.37,102.07 IC14.11
PIA-A0  (via drill 0.61)
  Top 0.254: v53.97,73.5 53.97,75.4 IC25.18 54.61,77.3 54.61,82.39 55.24,83.02 v55.24,91.28 | v48.89,73.5 50.16,72.22 50.16,67.14 46.98,63.97 46.98,62.06 v46.35,61.43 | IC12.3 20.95,70.32 20.95,72.86 20.31,73.5 20.31,74.77 19.68,75.4 19.68,77.94 17.77,79.84 v17.14,79.84 17.14,83.02 19.68,85.56 19.68,93.18 20.31,93.81 IC14.3 20.95,93.18 v20.95,91.91 | IC11.3 20.95,55.08 20.95,53.81 22.22,52.54 22.22,50 21.58,49.37 21.58,46.82 20.95,46.19 20.95,44.92 IC10.3 20.95,42.38 v20.95,41.11 | IC6.3 20.31,6.18 19.68,6.82 19.68,14.44 20.95,15.71 20.95,16.98 IC7.3 20.95,19.52 20.95,23.33 19.68,24.6 19.68,27.14 20.95,28.41 20.95,29.68 IC8.3 20.95,32.22 20.95,35.39 v19.68,36.66 | v92.07,10.63 92.07,6.82 IC2.2 | v92.07,15.71 92.07,16.98 IC3.2 | v90.8,34.76 90.8,32.22 91.44,31.58 IC4.2 92.07,29.68 92.07,28.41 90.8,27.14 v90.8,22.06 | v93.34,34.76 93.34,39.84 92.07,41.11 92.07,42.38 IC9.2 92.07,44.92 92.07,46.19 92.7,46.82 92.7,48.73 v93.34,49.37 | v90.8,49.37 90.8,55.08 91.44,55.71 IC15.2 92.07,57.62 92.07,60.8 v90.8,62.06 | v92.07,66.51 92.07,67.78 IC16.2 | v84.45,22.06 v84.45,15.08 v84.45,11.27 | v43.18,70.32 v43.18,73.5
  Bottom 0.254: v53.97,73.5 53.34,72.86 49.53,72.86 v48.89,73.5 v43.18,73.5 | v46.35,61.43 48.26,61.43 SV9.1 | v17.14,79.84 20.31,79.84 20.95,80.48 IC13.3 | v55.24,91.28 27.93,91.28 27.3,91.91 v20.95,91.91 | v20.95,41.11 19.68,39.84 v19.68,36.66 | 91.44,11.27 90.8,11.9 90.8,14.44 v92.07,15.71 | 91.44,11.27 v92.07,10.63 | v90.8,34.76 v93.34,34.76 | v93.34,49.37 v90.8,49.37 | v92.07,66.51 90.8,65.24 v90.8,62.06 | v84.45,11.27 91.44,11.27 | v84.45,22.06 v90.8,22.06 | v84.45,15.08 83.81,15.71 74.29,15.71 73.66,16.34 55.24,16.34 53.97,15.08 37.46,15.08 36.83,15.71 23.49,15.71 22.86,16.34 21.58,16.34 20.95,16.98 IC7.3 | v43.18,70.32 47.62,70.32 48.26,70.95 91.44,70.95 92.07,70.32 IC16.2
PIA-A1  (via drill 0.61)
  Top 0.254: IC6.4 22.86,6.18 22.22,6.82 v22.22,10 22.22,15.71 22.86,16.34 22.86,17.61 IC7.4 23.49,19.52 23.49,21.42 22.86,22.06 22.86,23.96 22.22,24.6 22.22,28.41 22.86,29.04 22.86,30.31 IC8.4 23.49,32.22 23.49,34.76 22.22,36.03 22.22,42.38 22.86,43.02 IC10.4 24.12,44.28 24.76,44.92 24.76,52.54 23.49,53.81 23.49,55.08 IC11.4 22.86,56.98 22.22,57.62 22.22,65.24 23.49,66.51 23.49,67.78 IC12.4 23.49,70.32 v23.49,72.22 23.49,72.86 22.22,74.13 22.22,80.48 22.86,81.11 IC13.4 23.49,83.02 23.49,85.56 22.86,86.19 22.86,87.47 22.22,88.1 22.22,90.64 22.86,91.28 22.86,93.81 IC14.4 | v99.69,2.38 99.69,4.28 IC2.5 | v29.84,9.36 v29.84,2.38 | IC16.5 99.69,67.78 99.69,66.51 100.96,65.24 100.96,60.8 100.32,60.16 100.32,56.98 IC15.5 100.32,55.71 100.96,55.08 100.96,48.73 99.69,47.46 v99.69,46.82 99.69,44.92 IC9.5 99.69,42.38 99.69,41.11 100.96,39.84 100.96,37.3 99.69,36.03 99.69,32.22 IC4.5 99.69,29.68 99.69,28.41 100.96,27.14 100.96,24.6 100.32,23.96 100.32,22.06 99.69,21.42 99.69,19.52 IC3.5 | v57.15,72.86 57.15,76.03 IC25.17 | v55.24,72.22 v55.24,65.24 | v43.18,40.48 42.54,41.11 42.54,49.37 43.81,50.63 43.81,51.91 43.18,52.54 43.18,55.08 42.54,55.71 42.54,58.89 v43.18,59.52
  Bottom 0.254: v99.69,2.38 99.05,1.74 30.47,1.74 v29.84,2.38 | v29.84,9.36 29.2,10 25.39,10 24.76,9.36 22.86,9.36 v22.22,10 | v57.15,72.86 55.88,72.86 v55.24,72.22 54.61,71.59 24.12,71.59 v23.49,72.22 | v55.24,65.24 52.7,65.24 52.7,63.34 51.43,62.06 SV9.3 51.43,60.8 50.16,59.52 v43.18,59.52 | v99.69,46.82 99.05,46.19 96.52,46.19 95.88,46.82 80.64,46.82 74.92,41.11 64.13,41.11 63.5,40.48 50.8,40.48 50.16,41.11 48.26,41.11 47.62,40.48 v43.18,40.48
PIA-A2  (via drill 0.61)
  Top 0.254: IC7.7 30.47,18.88 30.47,20.79 29.84,21.42 v29.84,22.7 29.84,27.14 31.11,28.41 31.11,29.68 IC8.7 31.11,32.22 31.11,34.76 29.84,36.03 v29.84,41.11 | v102.23,21.42 102.23,19.52 IC3.6 | v93.34,7.46 v93.34,21.42 93.34,27.14 95.88,29.68 95.88,32.22 v94.61,33.49 | v42.54,22.7 41.91,22.06 41.91,13.81 42.54,13.17 v42.54,7.46 | IC9.6 102.23,44.92 102.23,46.19 103.5,47.46 v103.5,48.09 103.5,52.54 102.23,53.81 102.23,55.08 IC15.6 | IC13.7 31.74,81.11 31.74,79.84 32.38,79.21 v32.38,74.13 32.38,72.86 34.92,70.32 v34.92,67.14 | v43.18,60.8 43.18,62.06 45.08,63.97 45.08,74.13 v44.45,74.77 | v93.34,72.86 v94.61,74.13 | v36.19,104.61 36.19,105.88 34.92,105.88 32.38,103.34 32.38,99.53 31.74,98.89 31.74,95.08 IC14.7 | v40.64,103.97 40.64,86.83 40,86.19 40,79.21 40.64,78.58 v40.64,67.78 | v51.43,74.13 51.43,73.5 52.7,72.22 52.7,62.06 53.34,61.43 SV9.5 | v79.37,46.82 80,47.46 80,68.41 79.37,69.05 79.37,72.22 v80,72.86 | v73.02,34.12 v73.02,46.82
  Bottom 0.254: v29.84,41.11 31.11,42.38 IC10.7 | 93.34,8.09 44.45,8.09 43.81,7.46 v42.54,7.46 31.74,7.46 31.11,6.82 IC6.7 | 93.34,8.09 99.05,8.09 99.69,7.46 101.59,7.46 102.23,6.82 IC2.6 | v93.34,21.42 v102.23,21.42 | 93.34,8.09 v93.34,7.46 | IC4.6 102.23,32.22 100.96,32.22 100.32,32.85 95.24,32.85 v94.61,33.49 83.81,33.49 83.18,34.12 v73.02,34.12 | v29.84,22.7 29.84,22.06 41.91,22.06 v42.54,22.7 | 58.41,74.77 59.05,75.4 IC25.16 | 51.43,74.77 v44.45,74.77 41.91,74.77 41.27,74.13 v32.38,74.13 | 58.41,74.77 51.43,74.77 | v43.18,60.8 38.73,60.8 37.46,59.52 36.83,59.52 35.55,58.25 31.74,58.25 31.11,57.62 IC11.7 | IC12.7 31.11,67.78 32.38,67.78 33.02,67.14 v34.92,67.14 40,67.14 v40.64,67.78 | v94.61,74.13 95.24,73.5 95.88,73.5 96.52,74.13 100.96,74.13 101.59,74.77 102.23,74.77 104.77,72.22 103.5,70.95 102.86,70.95 102.23,70.32 IC16.6 | v93.34,72.86 92.7,73.5 80,73.5 | 80,73.5 67.94,73.5 66.67,74.77 58.41,74.77 | v36.19,104.61 36.83,104.61 37.46,103.97 v40.64,103.97 | 51.43,74.77 v51.43,74.13 | v103.5,48.09 99.69,48.09 98.42,46.82 97.15,46.82 96.52,47.46 80,47.46 | 80,47.46 v79.37,46.82 | v80,72.86 80,73.5 | v73.02,46.82 73.66,46.82 74.29,47.46 80,47.46
PIA-A3  (via drill 0.61)
  Top 0.254: IC14.8 33.02,93.81 33.02,91.28 32.38,90.64 32.38,86.83 33.02,86.19 33.02,82.39 IC13.8 34.29,81.11 34.92,80.48 v34.92,72.86 | v62.86,65.24 62.86,70.32 62.23,70.95 62.23,76.03 IC25.15 61.59,75.4 v61.59,73.5 | IC9.9 109.85,44.92 109.85,48.73 108.58,50 108.58,52.54 109.85,53.81 109.85,55.08 IC15.9 109.21,56.98 109.21,60.16 108.58,60.8 108.58,67.14 | 108.58,67.14 108.58,67.78 109.21,68.41 IC16.9 | IC2.9 109.21,6.18 109.21,9.36 108.58,10 108.58,14.44 109.85,15.71 109.85,16.98 IC3.9 109.85,19.52 109.85,20.15 109.21,20.79 109.21,23.96 108.58,24.6 108.58,28.41 109.21,29.04 109.21,30.31 IC4.9 | IC10.8 33.65,44.92 33.65,46.19 34.92,47.46 v34.92,49.37 34.92,52.54 33.65,53.81 33.65,55.08 IC11.8 33.02,56.98 33.02,58.25 32.38,58.89 32.38,66.51 33.02,67.14 33.02,68.41 IC12.8 | v37.46,16.34 37.46,7.46 35.55,7.46 34.29,6.18 IC6.8 | IC7.8 34.29,18.88 34.29,22.7 34.92,23.33 34.92,29.68 34.29,30.31 IC8.8 33.65,32.22 33.65,34.76 v34.29,34.76 | v37.46,34.76 v37.46,41.11 | 108.58,67.14 104.13,67.14 103.5,66.51 103.5,62.06 v101.59,60.16 | v96.52,60.16 95.88,59.52 v95.88,34.12 | v56.51,58.89 56.51,60.8 SV9.7 | v46.35,58.25 45.72,57.62 45.72,56.35 45.08,55.71 45.08,50 v45.72,49.37
  Bottom 0.254: v62.86,65.24 58.41,65.24 57.78,64.61 57.78,62.7 57.15,62.06 56.51,62.06 SV9.7 | v34.92,72.86 35.55,72.22 53.97,72.22 55.88,74.13 60.96,74.13 v61.59,73.5 | v37.46,16.34 34.29,16.34 33.65,16.98 IC7.8 | v37.46,41.11 34.92,41.11 33.65,42.38 IC10.8 | v34.29,34.76 v37.46,34.76 38.73,34.76 42.54,30.95 53.97,30.95 54.61,30.31 74.92,30.31 76.19,29.04 103.5,29.04 | 103.5,29.04 109.21,29.04 109.85,29.68 IC4.9 | v96.52,60.16 v101.59,60.16 | v95.88,34.12 95.88,33.49 100.96,33.49 101.59,32.85 102.86,32.85 103.5,32.22 103.5,29.04 | v56.51,58.89 46.98,58.89 v46.35,58.25 | v34.92,49.37 v45.72,49.37
PIA-A4  (via drill 0.61)
  Top 0.254: IC2.12 110.48,13.81 110.48,16.34 111.12,16.98 111.12,20.15 109.85,21.42 109.85,24.6 IC3.12 110.48,26.5 110.48,29.04 111.12,29.68 111.12,32.22 109.85,33.49 109.85,37.3 IC4.12 110.48,39.2 110.48,41.74 111.12,42.38 111.12,44.92 110.48,45.55 110.48,50.63 IC9.12 110.48,51.91 110.48,54.45 111.12,55.08 111.12,57.62 109.85,58.89 109.85,62.7 IC15.12 110.48,64.61 110.48,65.88 111.12,66.51 111.12,70.32 109.85,71.59 109.85,75.4 IC16.12 109.85,77.94 v109.85,96.99 | v64.13,73.5 64.13,75.4 IC25.14 64.77,77.3 64.77,82.39 65.4,83.02 v65.4,88.1 | v60.32,72.22 v60.32,67.14 60.32,63.34 59.69,62.7 59.69,61.43 SV9.9 | v36.19,23.33 34.92,22.06 34.92,16.98 34.29,16.34 34.29,13.81 IC6.13 | IC8.13 33.02,39.2 33.02,40.48 32.38,41.11 32.38,44.92 33.02,45.55 33.02,46.82 v33.65,47.46 33.65,50 IC10.13 | v31.74,86.19 32.38,85.56 32.38,80.48 33.02,79.84 33.02,77.3 IC12.13 33.65,75.4 33.65,72.86 34.92,71.59 36.19,71.59 37.46,70.32 v37.46,62.06 38.73,60.8 38.73,60.16 37.46,58.89 v37.46,47.46 | v33.65,86.83 33.65,88.1 IC13.13 33.65,90.64 33.65,91.91 34.92,93.18 34.92,95.72 34.29,96.36 34.29,101.44 IC14.13 | v44.45,24.6 v44.45,36.66 | v43.18,64.61 v43.18,67.78 | v74.29,88.1 v74.29,96.36
  Bottom 0.254: v64.13,73.5 63.5,72.86 62.23,72.86 61.59,72.22 v60.32,72.22 | IC7.13 33.65,24.6 34.92,24.6 v36.19,23.33 36.83,22.7 41.27,22.7 43.18,24.6 v44.45,24.6 | v31.74,86.19 32.38,86.83 v33.65,86.83 | IC11.13 33.65,62.7 34.29,62.06 v37.46,62.06 40.64,62.06 v43.18,64.61 | v33.65,47.46 v37.46,47.46 | v44.45,36.66 34.29,36.66 33.65,37.3 IC8.13 | v60.32,67.14 43.81,67.14 v43.18,67.78 | v109.85,96.99 109.21,96.36 85.08,96.36 84.45,96.99 74.92,96.99 v74.29,96.36 | v65.4,88.1 v74.29,88.1
PIA-A5  (via drill 0.61)
  Top 0.254: IC15.15 102.23,65.24 102.23,66.51 103.5,67.78 103.5,70.32 102.23,71.59 102.23,75.4 IC16.15 102.23,77.94 v102.23,80.48 | v67.94,60.16 67.94,70.32 67.3,70.95 67.3,76.03 IC25.13 67.3,77.3 67.3,82.39 67.94,83.02 v67.94,86.83 | v61.59,59.52 61.59,60.8 SV9.11 | v88.26,80.48 88.26,86.19 85.72,88.73 84.45,88.73 v84.45,86.83 | IC9.15 102.23,50 102.23,47.46 101.59,46.82 101.59,45.55 100.96,44.92 100.96,41.11 101.59,40.48 101.59,39.2 IC4.15 101.59,37.94 101.59,32.85 100.96,32.22 100.96,28.41 101.59,27.77 101.59,26.5 IC3.15 | v33.02,10 31.74,11.27 31.74,12.54 IC6.14 | v43.81,22.06 v43.81,9.36 v43.81,3.01 | v31.11,36.03 31.11,37.3 IC8.14 | v29.84,34.76 29.84,29.68 27.3,27.14 v27.3,23.96 | v31.11,46.19 30.47,46.82 30.47,50.63 IC10.14 31.11,52.54 31.11,53.81 32.38,55.08 32.38,57.62 31.11,58.89 31.11,62.7 IC11.14 31.11,65.24 31.11,66.51 32.38,67.78 32.38,71.59 31.11,72.86 31.11,75.4 IC12.14 31.11,77.94 31.11,79.21 29.84,80.48 v29.84,84.92 29.84,88.1 30.47,88.73 IC13.14 31.11,90.64 31.11,91.91 29.84,93.18 29.84,96.99 31.11,98.26 31.11,100.8 IC14.14 | v47.62,37.3 v47.62,41.74 | v104.13,9.36 104.13,10 102.86,11.27 102.86,12.54 IC2.15 | v85.08,3.01 v85.08,10 | v80,27.14 80.64,26.5 80.64,11.27 80,10.63 v80,3.01
  Bottom 0.254: v67.94,60.16 67.3,59.52 v61.59,59.52 | v102.23,80.48 101.59,81.11 100.96,81.11 100.32,80.48 v88.26,80.48 | v84.45,86.83 v67.94,86.83 34.92,86.83 33.02,84.92 v29.84,84.92 | v33.02,10 43.18,10 v43.81,9.36 | v43.81,22.06 43.18,22.06 42.54,21.42 29.2,21.42 28.57,22.06 28.57,23.96 | 28.57,23.96 30.47,23.96 31.11,24.6 IC7.14 | v29.84,34.76 v31.11,36.03 42.54,36.03 43.18,35.39 44.45,35.39 46.35,37.3 v47.62,37.3 | 28.57,23.96 v27.3,23.96 | v31.11,46.19 31.74,45.55 34.29,45.55 34.92,44.92 34.92,42.38 35.55,41.74 36.83,41.74 37.46,42.38 38.1,41.74 v47.62,41.74 | v104.13,9.36 103.5,10 97.78,10 97.15,9.36 85.72,9.36 v85.08,10 | v85.08,3.01 84.45,2.38 80,2.38 | 80,2.38 44.45,2.38 v43.81,3.01 | v80,27.14 80.64,27.77 100.32,27.77 100.96,27.14 102.23,27.14 IC3.15 | 80,2.38 v80,3.01
PIA-A6  (via drill 0.61)
  Top 0.254: IC14.17 23.49,100.8 23.49,97.62 24.76,96.36 24.76,90.64 24.12,90 IC13.17 23.49,88.1 23.49,86.83 24.12,86.19 24.12,83.66 24.76,83.02 24.76,77.94 24.12,77.3 IC12.17 23.49,75.4 23.49,74.13 24.12,73.5 24.12,72.86 24.76,72.22 24.76,67.78 24.12,67.14 24.12,64.61 IC11.17 23.49,62.7 23.49,58.89 24.76,57.62 24.76,55.08 27.3,52.54 v27.3,49.37 27.3,42.38 24.12,39.2 IC8.17 23.49,37.3 23.49,36.03 24.12,35.39 24.12,32.85 24.76,32.22 24.76,28.41 24.12,27.77 24.12,26.5 IC7.17 23.49,24.6 23.49,22.7 24.12,22.06 24.12,20.15 24.76,19.52 24.76,14.44 24.12,13.81 IC6.17 | v99.69,72.86 99.69,75.4 IC16.16 | v95.88,72.22 v95.88,65.88 v95.88,61.43 | v70.48,65.24 70.48,70.32 69.84,70.95 69.84,72.86 69.21,73.5 69.21,75.4 IC25.12 | v98.42,3.64 98.42,6.82 99.69,8.09 99.69,11.9 IC2.16 | v81.91,40.48 v81.91,10 v81.91,4.28 | IC3.16 99.05,26.5 99.05,29.04 98.42,29.68 98.42,32.22 99.05,32.85 99.05,37.94 IC4.16 99.05,39.2 99.05,41.74 98.42,42.38 98.42,47.46 99.69,48.73 99.69,50 IC9.16 | v84.45,59.52 83.81,58.89 83.81,44.28 v84.45,43.65
  Bottom 0.254: v27.3,49.37 24.12,49.37 23.49,50 IC10.17 | 98.42,72.86 v99.69,72.86 | 98.42,72.86 94.61,72.86 93.34,74.13 71.75,74.13 71.11,74.77 69.84,74.77 69.21,75.4 IC25.12 | v95.88,65.88 99.05,65.88 99.69,65.24 IC15.16 | v95.88,72.22 97.78,72.22 98.42,72.86 | v70.48,65.24 65.4,65.24 65.4,63.34 64.13,62.06 SV9.13 | v98.42,3.64 97.78,3.01 88.26,3.01 86.99,4.28 v81.91,4.28 | 84.45,40.48 99.05,40.48 99.69,39.84 IC4.16 | v81.91,40.48 84.45,40.48 | v95.88,61.43 91.44,61.43 89.53,59.52 v84.45,59.52 | 84.45,40.48 v84.45,43.65 | v81.91,10 81.27,9.36 52.7,9.36 51.43,10.63 33.65,10.63 33.02,11.27 30.47,11.27 29.84,11.9 29.2,11.27 25.39,11.27 24.76,11.9 23.49,11.9 IC6.17
PIA-A7  (via drill 0.61)
  Top 0.254: IC6.18 21.58,13.81 21.58,16.34 22.22,16.98 22.22,23.33 21.58,23.96 21.58,25.23 IC7.18 21.58,26.5 21.58,29.04 22.22,29.68 22.22,32.22 21.58,32.85 21.58,37.94 IC8.18 20.31,39.2 19.68,39.84 19.68,44.92 20.31,45.55 20.31,46.82 20.95,47.46 20.95,50 IC10.18 20.31,51.91 20.31,54.45 19.68,55.08 19.68,58.89 20.31,59.52 20.31,63.34 IC11.18 21.58,64.61 21.58,65.88 22.22,66.51 22.22,72.86 20.95,74.13 20.95,75.4 IC12.18 20.31,77.3 20.31,78.58 19.68,79.21 19.68,84.29 20.31,84.92 20.31,88.73 IC13.18 | IC14.18 20.95,100.8 20.95,96.99 22.22,95.72 22.22,91.91 21.58,91.28 21.58,90 IC13.18 | v65.4,72.22 65.4,63.34 66.03,62.7 66.03,61.43 SV9.15 | v71.75,72.22 71.75,75.4 IC25.11 71.75,77.94 71.75,78.58 70.48,79.84 v70.48,82.39 | IC2.19 91.44,13.81 90.8,14.44 90.8,20.15 92.07,21.42 92.07,24.6 IC3.19 92.7,26.5 92.7,29.04 93.34,29.68 93.34,32.85 92.07,34.12 92.07,37.3 IC4.19 91.44,39.2 91.44,41.74 90.8,42.38 90.8,44.92 91.44,45.55 91.44,46.82 92.07,47.46 92.07,50 IC9.19 92.07,52.54 92.07,53.81 93.34,55.08 93.34,59.52 92.7,60.16 92.7,63.34 IC15.19 91.44,64.61 90.8,65.24 90.8,72.22 91.44,72.86 91.44,76.03 IC16.19 | v22.22,84.29 22.22,86.83 21.58,87.47 21.58,88.73 IC13.18
  Bottom 0.254: IC25.11 71.75,75.4 72.38,74.77 91.44,74.77 92.07,75.4 IC16.19 | v71.75,72.22 v65.4,72.22 | v22.22,84.29 24.76,84.29 25.39,83.66 29.84,83.66 30.47,84.29 33.65,84.29 35.55,86.19 67.3,86.19 67.94,85.56 67.94,82.39 v70.48,82.39
PIA-B0
  Top 0.254: IC5.23 48.89,22.06 47.62,23.33 47.62,36.03 48.89,37.3 48.89,42.38 IC1.23 48.89,44.92 47.62,46.19 47.62,62.06 48.89,63.34 SV9.2
  Bottom 0.254: IC26.18 53.34,55.71 50.8,53.17 31.74,53.17 29.84,55.08 29.84,60.8 37.46,60.8 38.1,61.43 42.54,61.43 45.08,63.97 48.26,63.97 SV9.2
PIA-B1  (via drill 0.61)
  Top 0.254: IC5.22 50.8,21.42 50.16,22.06 50.16,29.68 51.43,30.95 51.43,42.38 IC1.22 50.8,44.28 50.8,45.55 50.16,46.19 v50.16,51.27 50.16,63.34 50.8,63.97 SV9.4 | v56.51,51.27 56.51,55.08 IC26.17
  Bottom 0.254: v50.16,51.27 v56.51,51.27
PIA-B2  (via drill 0.61)
  Top 0.254: v59.05,59.52 59.05,57.62 IC26.16 59.05,55.08 v59.05,53.17 | IC5.21 53.97,22.06 53.97,24.6 52.7,25.87 52.7,37.3 53.97,38.57 53.97,42.38 IC1.21 53.97,44.92 53.97,45.55 53.34,46.19 53.34,46.82 52.7,47.46 v52.7,53.17
  Bottom 0.254: v59.05,59.52 57.15,59.52 56.51,60.16 55.88,60.16 55.24,60.8 55.24,62.06 53.97,63.34 SV9.6 | v52.7,53.17 v59.05,53.17
PIA-B3  (via drill 0.61)
  Top 0.254: IC5.20 56.51,22.06 56.51,23.96 55.24,25.23 55.24,29.68 56.51,30.95 56.51,42.38 IC1.20 56.51,44.92 56.51,45.55 55.24,46.82 v55.24,54.45 55.24,63.34 55.88,63.97 SV9.8
  Bottom 0.254: v55.24,54.45 60.96,54.45 61.59,55.08 IC26.15
PIA-B4
  Top 0.254: IC5.18 61.59,22.06 62.86,23.33 62.86,51.27 64.13,52.54 64.13,55.08 IC26.14
  Bottom 0.254: SV9.10 59.05,63.34 60.32,62.06 60.32,58.25 62.23,58.25 63.5,56.98 IC26.14
PIA-B5  (via drill 0.61)
  Top 0.254: v66.67,52.54 66.67,55.08 IC26.13 | IC1.18 60.96,44.28 60.32,44.92 v60.32,52.54 60.32,62.06 60.96,62.7 60.96,63.97 SV9.12
  Bottom 0.254: v60.32,52.54 v66.67,52.54
PIA-B6
  Top 0.254: IC26.12 68.57,56.98 65.4,60.16 65.4,62.06 64.13,63.34 SV9.14
PIA-B7  (via drill 0.61)
  Top 0.254: v70.48,62.7 70.48,57.62 71.11,56.98 IC26.11
  Bottom 0.254: v70.48,62.7 67.3,62.7 66.67,63.34 SV9.16
R/W\  (via drill 0.61)
  Top 0.254: v199.38,60.16 199.38,82.39 200.02,83.02 v200.02,88.73 v200.02,94.45 | v206.37,94.45 206.37,98.26 IC21.13 | v119.38,99.53 120.01,98.89 v120.01,86.19 | v135.88,62.7 135.88,63.34 133.34,65.88 133.34,82.39 133.98,83.02 v133.98,86.19 v133.98,99.53 | v175.25,89.37 174.62,90 174.62,98.26 v175.25,98.89
  Bottom 0.254: v199.38,60.16 198.75,60.16 198.12,59.52 196.84,59.52 IC17.34 | v200.02,94.45 v206.37,94.45 | v119.38,99.53 97.78,99.53 IC24.21 | v133.98,86.19 v120.01,86.19 | v135.88,62.7 135.88,63.34 139.69,63.34 140.33,62.7 IC22.27 | v200.02,88.73 199.38,89.37 v175.25,89.37 | v175.25,98.89 167,98.89 166.37,99.53 163.82,99.53 163.19,100.16 158.75,100.16 158.11,99.53 v133.98,99.53
RST\  (via drill 0.61)
  Top 0.254: v205.1,67.78 v205.1,74.77 | v210.81,67.78 210.81,48.09 205.73,43.02 205.73,27.77 207,26.5 207,23.96 208.28,22.7 208.28,15.08 207.64,14.44 204.47,14.44 v204.47,9.36 | v64.13,89.37 64.13,98.26 IC24.34 | v81.91,88.73 84.45,91.28 93.34,91.28 v93.34,95.08 | v121.91,96.36 125.72,92.55 125.72,86.83 127.63,84.92 127.63,76.67 128.9,75.4 128.9,13.81 140.97,1.74 194.31,1.74 194.31,4.92 197.48,8.09 IC18.6
  Bottom 0.254: v205.1,74.77 201.29,74.77 200.66,74.13 197.48,74.13 IC17.40 | v210.81,67.78 v205.1,67.78 | v204.47,9.36 203.19,9.36 201.92,8.09 200.02,8.09 IC18.6 | v64.13,89.37 65.4,89.37 66.03,88.73 73.02,88.73 73.66,89.37 81.27,89.37 v81.91,88.73 | v93.34,95.08 93.34,95.72 121.28,95.72 v121.91,96.36
RX  (via drill 0.61)
  Top 0.254: v150.49,39.2 150.49,34.76 149.85,34.12 IC20.12 | v174.62,39.84 174.62,47.46 173.35,48.73 173.35,60.16 174.62,61.43 v174.62,79.21 | v180.97,79.21 180.97,83.02 IC21.2
  Bottom 0.254: v150.49,39.2 151.12,38.57 165.73,38.57 167,39.84 v174.62,39.84 | v180.97,79.21 v174.62,79.21
RXD
  Top 0.254: IC20.13 146.68,32.22 147.95,30.95 147.95,16.34 X1.2
TX  (via drill 0.61)
  Top 0.254: v152.39,58.89 152.39,48.09 151.76,47.46 151.76,34.76 IC20.11 | v133.34,63.34 v133.34,58.89 | v192.4,67.78 193.03,68.41 193.03,79.84 191.13,81.75 191.13,83.02 IC21.6
  Bottom 0.254: v133.34,58.89 v152.39,58.89 | v133.34,63.34 134.62,64.61 173.35,64.61 175.89,67.14 179.06,67.14 179.7,67.78 v192.4,67.78
TXD
  Top 0.254: IC20.14 144.14,32.22 145.41,30.95 145.41,16.34 X1.3
VCC  (via drill 0.61)
  Top 0.508: v178.43,56.35 178.43,54.45 R6.2 | IC17.35 196.21,62.06 196.21,63.34 IC17.36 | R5.2 191.13,78.58 191.13,77.3 R8.2 191.13,76.03 v191.13,63.97 | 206.37,67.78 207.64,66.51 IC28.16 | 206.37,67.78 206.37,83.02 IC21.12 | v197.48,102.7 197.48,97.62 196.84,96.99 196.84,86.19 196.21,85.56 IC21.8 196.21,83.02 v196.21,79.21 | v186.05,61.43 v186.05,56.35 | v173.35,13.17 v173.35,5.55 | v178.43,13.17 178.43,11.27 R12.2 | R2.2 188.59,18.88 188.59,20.15 R1.2 188.59,21.42 v188.59,23.33 | IC18.14 206.37,21.42 v206.37,23.33 206.37,25.87 205.1,27.14 v205.1,43.65 205.1,48.73 | v204.47,53.81 204.47,49.37 205.1,48.73 | v172.08,23.33 v172.08,15.71 | 206.37,67.78 206.37,65.88 205.1,64.61 205.1,56.35 205.73,55.71 205.73,49.37 205.1,48.73 | IC14.20 15.87,100.8 15.87,97.62 14.6,96.36 14.6,90.64 15.24,90 IC13.20 15.24,88.73 15.24,87.47 14.6,86.83 v14.6,79.84 | IC8.20 15.24,39.2 15.24,40.48 14.6,41.11 14.6,47.46 15.87,48.73 15.87,50 IC10.20 | IC11.20 15.24,64.61 14.6,65.24 14.6,75.4 15.24,76.03 IC12.20 | v3.17,79.21 v3.17,53.17 3.17,50 4.44,48.73 4.44,25.87 3.8,25.23 v3.8,14.44 | v46.35,54.45 46.35,53.81 46.98,53.17 46.98,44.28 IC1.24 46.35,42.38 v46.35,36.03 46.35,30.95 45.08,29.68 45.08,25.87 46.35,24.6 46.35,22.06 IC5.24 | 17.14,20.15 17.14,15.71 15.87,14.44 IC6.20 | 17.14,20.15 15.87,21.42 15.87,24.6 IC7.20 | v17.14,20.79 17.14,20.15 | IC2.20 88.89,13.81 88.26,14.44 88.26,20.15 89.53,21.42 89.53,24.6 IC3.20 88.89,26.5 88.26,27.14 88.26,32.85 89.53,34.12 v89.53,34.76 89.53,37.3 IC4.20 88.89,39.2 88.26,39.84 88.26,50 | 88.26,50 88.89,50.63 IC9.20 | 88.26,62.7 88.89,63.34 IC15.20 89.53,62.7 v89.53,61.43
  Top 0.508: 88.26,62.7 88.26,50 | 88.26,62.7 88.26,75.4 88.89,76.03 IC16.20 | R7.2 139.69,84.29 139.69,82.39 IC23.27 | IC29.28 137.79,100.8 137.79,88.1 IC29.1 137.79,85.56 137.79,83.02 IC23.28 137.79,80.48 137.79,67.78 IC23.1 137.79,65.24 137.79,62.7 IC22.28 137.79,60.16 v137.79,53.81 137.79,47.46 IC22.1 137.79,44.92 137.79,34.76 138.42,34.12 IC20.16 | v133.98,33.49 133.98,23.96 C10.1 | 113.66,24.6 113.66,14.44 113.02,13.81 IC2.11 | 113.66,24.6 113.02,25.23 IC3.11 | 113.66,24.6 113.66,32.22 112.39,33.49 112.39,37.3 IC4.11 113.02,39.2 113.66,39.84 113.66,47.46 112.39,48.73 112.39,50 IC9.11 113.02,51.91 113.66,52.54 113.66,60.16 112.39,61.43 112.39,62.7 IC15.11 113.02,64.61 113.66,65.24 113.66,75.4 113.02,76.03 IC16.11 112.39,77.94 v112.39,81.75 | IC24.22 94.61,98.26 94.61,90.64 97.15,88.1 97.15,85.56 IC24.20 97.15,83.02 v97.15,81.75 97.15,79.84 v96.52,79.21
  Bottom 0.508: v178.43,56.35 179.7,56.35 IC17.8 182.24,56.35 v186.05,56.35 | 200.66,86.19 196.84,86.19 196.21,85.56 IC21.8 | 200.66,86.19 201.29,85.56 IC21.10 | 200.66,86.19 205.73,86.19 206.37,85.56 IC21.12 | v197.48,102.7 181.6,102.7 180.97,103.34 JP2.2 | v196.21,79.21 191.76,79.21 R5.2 | v191.13,63.97 194.94,63.97 IC17.36 | v186.05,61.43 194.94,61.43 IC17.35 | R12.2 179.06,10.63 180.34,10.63 R3.2 | v173.35,5.55 175.25,5.55 R9.2 | v178.43,13.17 177.16,13.17 IC27.10 174.62,13.17 v173.35,13.17 170.81,13.17 168.91,15.08 IC27.4 169.54,15.71 v172.08,15.71 | v206.37,23.33 v188.59,23.33 177.16,23.33 IC27.14 174.62,23.33 v172.08,23.33 | v205.1,43.65 207.64,43.65 IC19.16 | v204.47,53.81 202.56,53.81 IC28.6 | v3.17,53.17 15.24,53.17 15.87,52.54 IC10.20 | v3.17,79.21 6.34,79.21 6.98,79.84 v14.6,79.84 15.24,79.84 16.5,78.58 15.87,77.94 IC12.20 | v46.35,54.45 46.35,55.08 47.62,56.35 48.26,56.35 IC26.20 | v17.14,20.79 45.72,20.79 IC5.24 | v3.8,14.44 11.43,14.44 12.7,13.17 15.24,13.17 IC6.20 | IC25.20 48.89,77.94 48.26,77.94 47.62,78.58 47.62,80.48 50.16,80.48 52.07,78.58 77.46,78.58 78.1,77.94 85.72,77.94 86.99,76.67 88.89,76.67 IC16.20 89.53,77.94 90.16,78.58 95.88,78.58 v96.52,79.21 | SV9.17 69.84,61.43 71.11,61.43 SV9.19 72.38,61.43 v89.53,61.43 | IC29.28 138.42,102.07 139.69,102.07 IC29.27 | IC23.27 139.69,81.75 138.42,81.75 IC23.28 137.16,81.75 v112.39,81.75 100.32,81.75 R14.2 99.05,81.75 v97.15,81.75 | v133.98,33.49 138.42,33.49 IC20.16 | IC24.24 89.53,100.8 90.16,101.44 93.97,101.44 94.61,100.8 IC24.22 | v46.35,36.03 46.98,35.39 57.78,35.39 58.41,36.03 73.66,36.03 74.92,34.76 v89.53,34.76
  Bottom 0.508: v137.79,53.81 161.28,53.81 161.92,54.45 178.43,54.45 R6.2
VMA  (via drill 0.61)
  Top 0.254: v203.19,8.09 202.56,8.73 202.56,23.33 v203.83,24.6 | v177.79,24.6 177.79,28.41 177.16,29.04 177.16,44.92 179.7,47.46 182.88,47.46 182.88,59.52 182.24,60.16 182.88,60.8 182.88,63.34 182.24,63.97 IC17.5
  Bottom 0.254: v203.19,8.09 205.1,8.09 IC18.9 | v203.83,24.6 203.19,23.96 189.22,23.96 188.59,24.6 187.95,24.6 187.32,23.96 178.43,23.96 v177.79,24.6

## Text on the board
tPlace: Bypass Caps?